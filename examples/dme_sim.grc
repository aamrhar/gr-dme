<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dme_sim</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_function_probe</key>
<param><key>id</key><value>auto_dist</value></param>
<param><key>block_id</key><value>avio505_utils_test_funcs_0</value></param>
<param><key>function_name</key><value>delay_stim</value></param>
<param><key>value</key><value>0</value></param>
<param><key>poll_rate</key><value>0.2</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>auto_distx</value></param>
<param><key>value</key><value>auto_dist</value></param>
<param><key>label</key><value>auto_dist</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>delay</value></param>
<param><key>value</key><value>int(2*dme_d*1852*1e6/3e8)+50</value></param>
<param><key>label</key><value>delay</value></param>
<param><key>type</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>dme_d</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>dme_d</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>vor_freq</value></param>
<param><key>value</key><value>108</value></param>
</block>
<block>
<key>avio505_utils_logger</key>
<param><key>id</key><value>avio505_utils_logger_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file_prefix</key><value>/home/lassena/Documents/dme_utest.txt</value></param>
<param><key>max_lines</key><value>1000</value></param>
</block>
<block>
<key>avio505_utils_pmt_print</key>
<param><key>id</key><value>avio505_utils_pmt_print_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>avio505_utils_test_funcs</key>
<param><key>id</key><value>avio505_utils_test_funcs_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>int(2*auto_dist*1852*1e6/3e8)+50</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>int(2*dme_d*1852*1e6/3e8)+50</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_1</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_1_0</value></param>
<param><key>msg</key><value>pmt.intern("TEST")</value></param>
<param><key>period</key><value>1000</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0.5</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_null_source</key>
<param><key>id</key><value>blocks_null_source_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>int</value></param>
<param><key>vlen</key><value>2</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>dme_dme_rx</key>
<param><key>id</key><value>dme_dme_rx_0</value></param>
<param><key>id_num</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>freq_vor</key><value>vor_freq</value></param>
</block>
<block>
<key>dme_dme_rx</key>
<param><key>id</key><value>dme_dme_rx_0_0</value></param>
<param><key>id_num</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>freq_vor</key><value>vor_freq</value></param>
</block>
<block>
<key>dme_dme_time</key>
<param><key>id</key><value>dme_dme_time_0</value></param>
</block>
<block>
<key>dme_dme_tx</key>
<param><key>id</key><value>dme_dme_tx_0</value></param>
<param><key>vor_freq</key><value>vor_freq</value></param>
<param><key>id_num</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>dme_fpga_clk32_sim</key>
<param><key>id</key><value>dme_fpga_clk32_sim_0</value></param>
<param><key>inc</key><value>40</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_0</value></param>
<param><key>address</key><value>tcp://127.0.0.1:1234</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<block>
<key>zeromq_pull_msg_source</key>
<param><key>id</key><value>zeromq_pull_msg_source_1</value></param>
<param><key>address</key><value>tcp://127.0.0.1:1234</value></param>
<param><key>timeout</key><value>100</value></param>
</block>
<connection><source_block_id>avio505_utils_test_funcs_0</source_block_id><sink_block_id>blocks_message_strobe_1_0</sink_block_id><source_key>log</source_key><sink_key>set_msg</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>dme_dme_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_0</source_block_id><sink_block_id>blocks_throttle_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_1</source_block_id><sink_block_id>blocks_throttle_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_null_source_1_0</source_block_id><sink_block_id>dme_dme_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>dme_fpga_clk32_sim_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0_0</source_block_id><sink_block_id>dme_fpga_clk32_sim_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_throttle_1</source_block_id><sink_block_id>dme_dme_rx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0</source_block_id><sink_block_id>avio505_utils_logger_0</sink_block_id><source_key>dist</source_key><sink_key>msg</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0</source_block_id><sink_block_id>avio505_utils_test_funcs_0</sink_block_id><source_key>dist</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0</source_block_id><sink_block_id>dme_dme_tx_0</sink_block_id><source_key>to_tx</source_key><sink_key>from_rx</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>dist</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0_0</source_block_id><sink_block_id>blocks_message_debug_1</sink_block_id><source_key>to_tx</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dme_dme_rx_0_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dme_dme_time_0</source_block_id><sink_block_id>dme_dme_rx_0</sink_block_id><source_key>dme1</source_key><sink_key>tx_detector</sink_key></connection>
<connection><source_block_id>dme_dme_time_0</source_block_id><sink_block_id>blocks_message_strobe_0</sink_block_id><source_key>dme2</source_key><sink_key>set_msg</sink_key></connection>
<connection><source_block_id>dme_dme_time_0</source_block_id><sink_block_id>dme_dme_rx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>dme_dme_tx_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>cmd_out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>dme_dme_tx_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dme_dme_tx_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dme_fpga_clk32_sim_0</source_block_id><sink_block_id>dme_dme_time_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>dme_dme_rx_0_0</sink_block_id><source_key>out</source_key><sink_key>cmd_in</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_0</source_block_id><sink_block_id>dme_dme_rx_0_0</sink_block_id><source_key>out</source_key><sink_key>tx_detector</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>zeromq_pull_msg_source_1</source_block_id><sink_block_id>dme_dme_rx_0</sink_block_id><source_key>out</source_key><sink_key>cmd_in</sink_key></connection>
</flow_graph>
